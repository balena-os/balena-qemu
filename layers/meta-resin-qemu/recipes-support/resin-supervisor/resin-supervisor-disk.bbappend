TARGET_REPOSITORY_qemux86-64 = "resin/amd64-supervisor"
LED_FILE_qemux86-64 = "/dev/null"
