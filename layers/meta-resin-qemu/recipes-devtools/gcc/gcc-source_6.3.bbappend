
# This patch causes a build failure with stack protector on qemux86
SRC_URI_remove = "file://0041-ssp_nonshared.patch" 
