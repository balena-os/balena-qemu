# Increase size of data partition to something usable
PARTITION_SIZE = "2048"
